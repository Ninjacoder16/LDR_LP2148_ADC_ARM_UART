# Keil uVision project ARMBASEDstreetlightcontrol.uvproj, settings and files
target Target 1 (5020028::V5.02 [Build 28]::.\ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ARMBASEDstreetlightcontrol +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s ARMBASEDstreetlightcontrol.c
